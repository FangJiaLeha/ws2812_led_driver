# Keil uVision project project.uvprojx, settings and files
target gd32f330_led_driver (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F330F8 GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.2.0.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gd32f330_led_driver_V1.x.x +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 wLevel=2
  c include: ..\..\Firmware\CMSIS;..\..\Firmware\CMSIS\GD\GD32F3x0\Include;..\..\Firmware\GD32F3x0_standard_peripheral\Include;..\platform\bsp\inc;..\platform\function;..\platform\Inc;..\platform\test;..\..\Code
  memory RVCT4: ROM 0x8000000 size 0x1ffff
  memory RVCT9: RAM 0x20000000 size 0x3fff
  group Application
    ../: gd32f3x0_it.c main.c systick.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32F3x0/Source/: system_gd32f3x0.c
  group Peripherals
    ../../Firmware/GD32F3x0_standard_peripheral/Source/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
  group Platform
    ../platform/src/: board.c
  group HardLayerDriver
    ../platform/src/: drv_pwm.c drv_i2c.c drv_wdgt.c
  group AbsLayer
    ../platform/src/: led_frame.c
  group FuncLayer
    ../platform/src/: led_bar.c task_sch.c
    ../platform/function/: register_info.c
  group Bsp
    ../platform/bsp/src/: tlc59108.c tlc59108_led_bar.c ws2812.c ws2812_led_bar.c
  group Test
    ../platform/test/: test.c
