# Keil uVision project bootloader_project.uvprojx, settings and files
target GD32F330_Bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F330F8 GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.2.0.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gd32f330_ws2812_driver_bootloader +hex
  AfterMake: fromelf --bin !L --output ./Bin/gd32f330_ws2812_driver_bootloader.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 wLevel=2
  c include: ..\..\Template;..\..\Firmware\GD32F3x0_standard_peripheral\Include;..\..\Firmware\CMSIS;..\..\Template;..\..\Firmware\CMSIS\GD\GD32F3x0\Include;..\platform\Inc;..\platform\test;..\platform\iap;..\platform\common;..\platform\protocol
  memory RVCT4: ROM 0x8000000 size 0x4fff
  memory RVCT9: RAM 0x20000080 size 0x3faf
  group Application
    ../: gd32f3x0_it.c main.c systick.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32F3x0/Source/: system_gd32f3x0.c
  group Peripherals
    ../../Firmware/GD32F3x0_standard_peripheral/Source/: gd32f3x0_dbg.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_syscfg.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
  group Platform
    ../platform/src/: board.c drv_flash.c drv_i2c.c
  group IAP
    ../platform/iap/: iap.c bootloaderinfo.c
  group SystemCommon
    ../platform/common/: system_common.c
  group Protocol
    ../platform/protocol/: i2c_app.c crc.c
  group Test
    ../platform/test/: test.c
